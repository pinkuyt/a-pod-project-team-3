# Keil uVision project UART.uvproj, settings and files
target UART (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: UART +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX
  c include: ..\;..\..\Libraries\CMSIS\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK_ARM
    ../../Libraries/CMSIS/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32F4_StdPeriph
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_dma.c
  group User
    ../: main.c system_stm32f4xx.c sysTick.c sysTick.h button_init.c button_user.c led_init.c led1.c Usart.c Usart.h DMA_USART.c DMA_USART.h
